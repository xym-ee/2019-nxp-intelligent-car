<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\NJUST_smartcar.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>NJUST_smartcar</project>
                <configuration>Sdram_debug</configuration>
            </member>
            <member>
                <project>NJUST_smartcar</project>
                <configuration>Sdram_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Sdram_debug</name>
            <member>
                <project>NJUST_smartcar</project>
                <configuration>Sdram_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Sdram_release</name>
            <member>
                <project>NJUST_smartcar</project>
                <configuration>Sdram_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
